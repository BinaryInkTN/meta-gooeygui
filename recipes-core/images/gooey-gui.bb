SUMMARY = "Custom linux image for gooeygui" 
LICENSE = "CLOSED"
inherit core-image
# set image type 

IMAGE_FEATURES += " debug-tweaks"
